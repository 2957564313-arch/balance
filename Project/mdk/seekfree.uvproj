# Keil uVision project seekfree.uvproj, settings and files
target STC32G (MCS-251)
  device: AI32G12K128 Series AI
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: SEEKFREE +hex
  asm include: ..\..\libraries\zf_common
  link misc: REMOVEUNUSED
  group doc
    ../../libraries/doc/: version.txt
  group zf_common
    ../../libraries/zf_common/: START251.A51 stc32gxx.h stc32g_isr.asm zf_common_headfile.h zf_common_clock.c zf_common_clock.h zf_common_debug.c zf_common_debug.h zf_common_fifo.c zf_common_fifo.h zf_common_font.c zf_common_font.h zf_common_function.c zf_common_function.h zf_common_typedef.c zf_common_typedef.h zf_common_interrupt.c zf_common_interrupt.h
  group zf_driver
    ../../libraries/zf_driver/: zf_driver_adc.c zf_driver_adc.h zf_driver_delay.c zf_driver_delay.h zf_driver_eeprom.c zf_driver_eeprom.h zf_driver_encoder.c zf_driver_encoder.h zf_driver_exti.c zf_driver_exti.h zf_driver_gpio.c zf_driver_gpio.h zf_driver_pit.c zf_driver_pit.h zf_driver_pwm.c zf_driver_pwm.h zf_driver_spi.c zf_driver_spi.h zf_driver_timer.c zf_driver_timer.h zf_driver_uart.c zf_driver_uart.h
  group zf_device
    ../../Libraries/zf_device/: zf_device_imu660ra.c zf_device_imu660ra.h zf_device_config.c zf_device_config.h zf_device_config.lib
  group code
    ../code/: Key.c Key.h bluetooth.c bluetooth.h Buzzer.c Buzzer.h LED.c LED.h line.c line.h Menu.c Menu.h mode.c mode.h motor.c motor.h OLED.c OLED.h OLEDFONT.c OLEDFONT.h param.c param.h balance_control.c balance_control.h
  group user
    ../user/: isr.c isr.h main.c portint_stub.a51
